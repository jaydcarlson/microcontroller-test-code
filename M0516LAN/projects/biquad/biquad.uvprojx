# Keil uVision project biquad.uvprojx, settings and files
target biquad (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M0516LAN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: biquad
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\M051BSPv3\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ./: biquad.c
  group Lib
    ../../M051BSPv3/Library/StdDriver/src/: gpio.c acmp.c adc.c clk.c ebi.c fmc.c i2c.c pwm.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1, Device:Startup 3.01.001
