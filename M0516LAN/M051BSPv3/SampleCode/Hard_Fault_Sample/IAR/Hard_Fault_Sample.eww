<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Hard_Fault_Sample.ewp</path>
  </project>
  <batchBuild/>
</workspace>


