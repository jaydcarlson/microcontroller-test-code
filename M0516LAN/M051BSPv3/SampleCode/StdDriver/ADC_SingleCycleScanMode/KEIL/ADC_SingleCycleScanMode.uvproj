# Keil uVision project ADC_SingleCycleScanMode.uvproj, settings and files
target ADC_SingleCycleScanMode (ARM-ADS)
  device: (Generic) M051 Series Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: ADC_SingleCycleScanMode
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M051Series\Include;..\..\..\..\Library\CMSIS\Include
  library: MicroLIB
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
    ../../../../Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: uart.c retarget.c clk.c sys.c adc.c
