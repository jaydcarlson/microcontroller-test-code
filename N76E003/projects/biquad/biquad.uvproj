# Keil uVision project biquad.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: biquad
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\..\bsp\Include
  group Source Group 1
    ./: STARTUP.A51 biquad.c
