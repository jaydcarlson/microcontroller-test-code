# Keil uVision project SPI_Master_Interrupt.uvproj, settings and files
target SPI_INT_M (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: Master_P +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\..\Include
  group Source
    ./Code/: SPI_Master_Int.c
  group Common
    ../../../../Common/: Common.c Delay.c
  group Startup
    ../../../../Startup/: STARTUP.A51
