# Keil uVision project UCID.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: IAP_Read_UID +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Common;..\..\Include
  group Source Group 1
    ./Code/: UCID_check.C
  group Startup
    ../../Startup/: STARTUP.A51
  group Common
    ../../Common/: Delay.c Common.c
