# Keil uVision project dmx.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: dmx +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\bsp\Include
  group Source Group 1
    ./: STARTUP.A51 dmx.c
